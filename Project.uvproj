# Keil uVision project Project.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: ADC.c GLCD_SPI_LPC1700.c IRQ.c KBD.c LED.c PhotoGallery.c Main_Menu.c Main_Menu.h Game.c GameMenu.c Game2.c
  group Images
    ./: keanu.c tap.c enemy.c spaceship.c space.c spaceshipHurt.c white.c black.c
  group Configuration File
    ./: core_cm3.c
  group USB Audio Files
    ./: usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c adcuser.c
